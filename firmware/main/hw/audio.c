#include "audio.h"

#include <math.h>
#include <string.h>

#include "app_config.h"
#include "app_shared.h"
#include "board.h"
#include "core/byte_ring.h"
#include "core/vad.h"
#include "esp_heap_caps.h"
#include "esp_log.h"
#include "freertos/FreeRTOS.h"
#include "freertos/queue.h"
#include "freertos/semphr.h"
#include "freertos/task.h"
#include "net/backend.h"
#include "net/telemetry.h"

static const char *TAG = "audio";

// Spoken system messages, 16 kHz mono s16le (generated by tools/make_device_clips.py)
extern const uint8_t clip_not_understood_start[] asm("_binary_clip_not_understood_pcm_start");
extern const uint8_t clip_not_understood_end[] asm("_binary_clip_not_understood_pcm_end");
extern const uint8_t clip_no_speech_start[] asm("_binary_clip_no_speech_pcm_start");
extern const uint8_t clip_no_speech_end[] asm("_binary_clip_no_speech_pcm_end");
extern const uint8_t clip_error_start[] asm("_binary_clip_error_pcm_start");
extern const uint8_t clip_error_end[] asm("_binary_clip_error_pcm_end");
extern const uint8_t clip_timeout_start[] asm("_binary_clip_timeout_pcm_start");
extern const uint8_t clip_timeout_end[] asm("_binary_clip_timeout_pcm_end");
extern const uint8_t clip_offline_start[] asm("_binary_clip_offline_pcm_start");
extern const uint8_t clip_offline_end[] asm("_binary_clip_offline_pcm_end");

typedef enum {
    CMD_CAPTURE_START,
    CMD_CAPTURE_DISCARD,
    CMD_CAPTURE_SUBMIT,
    CMD_CUE,
    CMD_ERROR,
    CMD_STREAM,
    CMD_STOP,
} audio_cmd_type_t;

typedef struct {
    audio_cmd_type_t type;
    uint32_t turn;
    int arg;
} audio_cmd_t;

typedef enum { MODE_IDLE, MODE_CAPTURE, MODE_STREAM, MODE_CUE } audio_mode_t;

typedef struct {
    const int16_t *pcm;   // NULL = silence
    size_t samples;
} segment_t;

static QueueHandle_t s_cmd_q;
static bool s_speaker_ok, s_mic_ok;
static audio_stats_t s_stats;
static portMUX_TYPE s_stats_lock = portMUX_INITIALIZER_UNLOCKED;

// Capture state (audio task only)
static int16_t *s_cap_buf;            // PSRAM, AUDIO_MAX_CAPTURE_MS
static size_t s_cap_len;              // samples
static const size_t CAP_MAX = (size_t)AUDIO_SAMPLE_RATE * AUDIO_MAX_CAPTURE_MS / 1000;
static uint32_t s_cap_turn;
static uint32_t s_cap_start_ms;
static size_t s_cap_mute_samples;     // samples zeroed while the listen cue plays
static vad_t s_vad;
static bool s_endpoint_sent, s_limit_sent, s_early_fail_sent;

// Playback ring (shared with the network worker)
static byte_ring_t s_ring;
static SemaphoreHandle_t s_ring_mtx;
static uint32_t s_play_turn;          // turn allowed to write into the ring
static bool s_play_eof, s_play_failed;

// Earcons (generated at init)
static int16_t *s_cue_listen, *s_cue_cancel, *s_cue_error;
static size_t s_cue_listen_n, s_cue_cancel_n, s_cue_error_n;

// Cue program
static segment_t s_prog[4];
static int s_prog_n, s_prog_i;
static size_t s_prog_pos;
static bool s_prog_is_error;

static void stats_update(void (*fn)(audio_stats_t *, void *), void *arg)
{
    taskENTER_CRITICAL(&s_stats_lock);
    fn(&s_stats, arg);
    taskEXIT_CRITICAL(&s_stats_lock);
}

void audio_get_stats(audio_stats_t *out)
{
    taskENTER_CRITICAL(&s_stats_lock);
    *out = s_stats;
    taskEXIT_CRITICAL(&s_stats_lock);
}

// ---------------------------------------------------------------- earcons ---
static int16_t *make_tones(const float *freqs, const int *ms, int count, float amp, size_t *out_n)
{
    size_t total = 0;
    for (int i = 0; i < count; i++) total += (size_t)AUDIO_SAMPLE_RATE * ms[i] / 1000;
    int16_t *buf = heap_caps_malloc(total * sizeof(int16_t), MALLOC_CAP_SPIRAM | MALLOC_CAP_8BIT);
    if (!buf) return NULL;
    size_t p = 0;
    for (int i = 0; i < count; i++) {
        size_t n = (size_t)AUDIO_SAMPLE_RATE * ms[i] / 1000;
        size_t ramp = AUDIO_SAMPLE_RATE / 100;   // 10 ms raised-cosine ramps: no clicks
        for (size_t k = 0; k < n; k++) {
            float env = 1.f;
            if (k < ramp) env = 0.5f - 0.5f * cosf(3.14159265f * k / ramp);
            else if (k > n - ramp) env = 0.5f - 0.5f * cosf(3.14159265f * (n - k) / ramp);
            float s = sinf(2.f * 3.14159265f * freqs[i] * (float)k / AUDIO_SAMPLE_RATE);
            buf[p++] = (int16_t)(amp * env * s * 32767.f);
        }
    }
    *out_n = total;
    return buf;
}

static void make_earcons(void)
{
    // Listening: soft rising two-note chime (protocol Table 3).
    const float lf[] = {587.33f, 880.0f};
    const int lm[] = {90, 130};
    s_cue_listen = make_tones(lf, lm, 2, 0.22f, &s_cue_listen_n);
    // Cancel: short soft falling pair.
    const float cf[] = {659.25f, 493.88f};
    const int cm[] = {90, 120};
    s_cue_cancel = make_tones(cf, cm, 2, 0.18f, &s_cue_cancel_n);
    // Error: low two-note tone (non-alarming).
    const float ef[] = {392.0f, 329.63f};
    const int em[] = {160, 220};
    s_cue_error = make_tones(ef, em, 2, 0.20f, &s_cue_error_n);
}

// ------------------------------------------------------------- codec I/O ---
static int16_t s_stereo[AUDIO_FRAME_SAMPLES * 2];

static void write_mono(const int16_t *mono, size_t n)
{
    for (size_t i = 0; i < n; i++) s_stereo[2 * i] = s_stereo[2 * i + 1] = mono ? mono[i] : 0;
    if (s_speaker_ok) {
        esp_codec_dev_write(board_speaker(), s_stereo, (int)(n * 2 * sizeof(int16_t)));
    } else {
        vTaskDelay(pdMS_TO_TICKS(AUDIO_FRAME_MS));   // keep timing without a speaker
    }
}

static bool read_mono(int16_t *mono, size_t n, float *rms_l, float *rms_r)
{
    if (!s_mic_ok) return false;
    if (esp_codec_dev_read(board_mic(), s_stereo, (int)(n * 2 * sizeof(int16_t))) != ESP_CODEC_DEV_OK) return false;
    double el = 0, er = 0;
    for (size_t i = 0; i < n; i++) {
        int32_t l = s_stereo[2 * i], r = s_stereo[2 * i + 1];
        el += (double)l * l;
        er += (double)r * r;
        mono[i] = (int16_t)((l + r) / 2);
    }
    if (rms_l) *rms_l = (float)el;
    if (rms_r) *rms_r = (float)er;
    return true;
}

// -------------------------------------------------------- playback ring ----
void playback_begin(uint32_t turn)
{
    xSemaphoreTake(s_ring_mtx, portMAX_DELAY);
    ring_reset(&s_ring);
    s_play_turn = turn;
    s_play_eof = false;
    s_play_failed = false;
    xSemaphoreGive(s_ring_mtx);
}

int playback_push(uint32_t turn, const uint8_t *data, size_t len, uint32_t timeout_ms)
{
    size_t done = 0;
    uint32_t start = now_ms();
    while (done < len) {
        xSemaphoreTake(s_ring_mtx, portMAX_DELAY);
        if (s_play_turn != turn) {
            xSemaphoreGive(s_ring_mtx);
            return -1;
        }
        done += ring_write(&s_ring, data + done, len - done);
        xSemaphoreGive(s_ring_mtx);
        if (done < len) {
            if (now_ms() - start > timeout_ms) break;
            vTaskDelay(pdMS_TO_TICKS(10));
        }
    }
    return (int)done;
}

void playback_finish(uint32_t turn, bool failed)
{
    xSemaphoreTake(s_ring_mtx, portMAX_DELAY);
    if (s_play_turn == turn) {
        s_play_eof = true;
        s_play_failed = failed;
    }
    xSemaphoreGive(s_ring_mtx);
}

static void playback_reset(void)
{
    xSemaphoreTake(s_ring_mtx, portMAX_DELAY);
    s_play_turn = 0;
    ring_reset(&s_ring);
    xSemaphoreGive(s_ring_mtx);
}

// ------------------------------------------------------------- commands ----
static void send_cmd(audio_cmd_type_t t, uint32_t turn, int arg)
{
    audio_cmd_t c = {t, turn, arg};
    if (xQueueSend(s_cmd_q, &c, 0) != pdTRUE) ESP_LOGW(TAG, "audio command queue full (cmd %d)", t);
}

void audio_capture_start(uint32_t turn) { send_cmd(CMD_CAPTURE_START, turn, 0); }
void audio_capture_discard(void) { send_cmd(CMD_CAPTURE_DISCARD, 0, 0); }
void audio_capture_submit(uint32_t turn) { send_cmd(CMD_CAPTURE_SUBMIT, turn, 0); }
void audio_play_cue(audio_cue_t cue) { send_cmd(CMD_CUE, 0, cue); }
void audio_play_error(sm_error_t err) { send_cmd(CMD_ERROR, 0, err); }
void audio_stream_play(uint32_t turn) { send_cmd(CMD_STREAM, turn, 0); }
void audio_stop_playback(void)
{
    playback_reset();   // immediately stops the downloader from writing more
    send_cmd(CMD_STOP, 0, 0);
}

static segment_t clip(const uint8_t *s, const uint8_t *e)
{
    segment_t g = {(const int16_t *)s, (size_t)(e - s) / sizeof(int16_t)};
    return g;
}

static segment_t gap(int ms)
{
    segment_t g = {NULL, (size_t)AUDIO_SAMPLE_RATE * ms / 1000};
    return g;
}

static void program_start(bool is_error)
{
    s_prog_i = 0;
    s_prog_pos = 0;
    s_prog_is_error = is_error;
}

static void build_error_program(sm_error_t err)
{
    s_prog_n = 0;
    s_prog[s_prog_n++] = (segment_t){s_cue_error, s_cue_error_n};
    s_prog[s_prog_n++] = gap(180);
    switch (err) {
    case SM_ERR_NOT_UNDERSTOOD:
        s_prog[s_prog_n++] = clip(clip_not_understood_start, clip_not_understood_end);
        break;
    case SM_ERR_NO_SPEECH:
        s_prog[s_prog_n++] = clip(clip_no_speech_start, clip_no_speech_end);
        break;
    case SM_ERR_TIMEOUT:
        s_prog[s_prog_n++] = clip(clip_timeout_start, clip_timeout_end);
        break;
    default:
        s_prog[s_prog_n++] = clip(clip_error_start, clip_error_end);
        break;
    }
    s_prog[s_prog_n++] = gap(100);
    program_start(true);
}

// ------------------------------------------------------------ capture ------
static void capture_begin(uint32_t turn)
{
    dev_settings_t st;
    settings_get(&st);
    vad_config_t vc;
    vad_default_config(&vc);
    vc.abs_threshold_dbfs = st.vad_abs_dbfs;
    vc.snr_db = st.vad_snr_db;
    vad_reset(&s_vad, &vc);
    s_cap_len = 0;
    s_cap_turn = turn;
    s_cap_start_ms = now_ms();
    s_endpoint_sent = s_limit_sent = s_early_fail_sent = false;
    // the listen cue plays while capture starts; keep it out of the recording
    s_cap_mute_samples = s_cue_listen_n + AUDIO_SAMPLE_RATE * 60 / 1000;
    if (s_mic_ok) esp_codec_dev_set_in_mute(board_mic(), false);
    // listen cue program (overlaid on capture)
    s_prog_n = 0;
    s_prog[s_prog_n++] = (segment_t){s_cue_listen, s_cue_listen_n};
    program_start(false);
}

static void capture_stop_mic(void)
{
    if (s_mic_ok) esp_codec_dev_set_in_mute(board_mic(), true);
}

typedef struct { uint32_t ms; float rms; int32_t peak; uint32_t clipped; int q; } cap_stat_arg_t;
static void set_cap_stats(audio_stats_t *s, void *a)
{
    cap_stat_arg_t *c = a;
    s->capture_ms = c->ms;
    s->capture_rms_dbfs = c->rms;
    s->capture_peak = c->peak;
    s->capture_clipped = c->clipped;
    s->capture_quality = c->q;
}

static void capture_finish(uint32_t turn, bool submit)
{
    capture_stop_mic();
    uint32_t dur_ms = (uint32_t)(s_cap_len * 1000 / AUDIO_SAMPLE_RATE);
    capture_quality_t q = vad_quality(&s_vad);
    cap_stat_arg_t cs = {dur_ms, vad_rms_dbfs(&s_vad), s_vad.peak, s_vad.clipped_samples, q};
    stats_update(set_cap_stats, &cs);
    telemetry_log(TEL_CAPTURE_STATS, s_cap_turn, (int32_t)dur_ms, q, capture_quality_name(q));
    if (!submit) return;
    if (turn != s_cap_turn) {
        ESP_LOGW(TAG, "submit for turn %lu but capturing %lu", (unsigned long)turn, (unsigned long)s_cap_turn);
        ctrl_post_event(SM_EV_TURN_FAILED, turn, SM_ERR_CAPTURE);
        return;
    }
    if (q == CAPTURE_NO_SIGNAL) {
        // Distinguish a microphone/data-path fault from "nothing was said".
        ESP_LOGE(TAG, "capture contained no signal: microphone path fault");
        ctrl_post_event(SM_EV_TURN_FAILED, turn, SM_ERR_CAPTURE);
        return;
    }
    if (dur_ms < AUDIO_MIN_CAPTURE_MS) {
        ctrl_post_event(SM_EV_TURN_FAILED, turn, SM_ERR_NO_SPEECH);
        return;
    }
    if (!backend_submit_turn(turn, s_cap_buf, s_cap_len * sizeof(int16_t), dur_ms, q)) {
        ctrl_post_event(SM_EV_TURN_FAILED, turn, SM_ERR_BACKEND);
    }
}

static void capture_step(void)
{
    int16_t frame[AUDIO_FRAME_SAMPLES];
    if (!read_mono(frame, AUDIO_FRAME_SAMPLES, NULL, NULL)) {
        if (!s_early_fail_sent) {
            s_early_fail_sent = true;
            ESP_LOGE(TAG, "microphone read failed");
            ctrl_post_event(SM_EV_CAPTURE_FAILED, s_cap_turn, SM_ERR_CAPTURE);
        }
        vTaskDelay(pdMS_TO_TICKS(AUDIO_FRAME_MS));
        return;
    }
    size_t muted = 0;
    if (s_cap_mute_samples > 0) {
        muted = s_cap_mute_samples < AUDIO_FRAME_SAMPLES ? s_cap_mute_samples : AUDIO_FRAME_SAMPLES;
        memset(frame, 0, muted * sizeof(int16_t));
        s_cap_mute_samples -= muted;
    }
    if (s_cap_len + AUDIO_FRAME_SAMPLES <= CAP_MAX) {
        memcpy(s_cap_buf + s_cap_len, frame, sizeof(frame));
        s_cap_len += AUDIO_FRAME_SAMPLES;
    } else if (!s_limit_sent) {
        s_limit_sent = true;
        ctrl_post_event(SM_EV_CAPTURE_LIMIT, s_cap_turn, 0);
    }
    if (muted == AUDIO_FRAME_SAMPLES) return;   // cue period is not analysed

    vad_frame_t f;
    if (vad_process(&s_vad, frame, AUDIO_FRAME_SAMPLES, &f)) {
        ctrl_post_event(SM_EV_SPEECH_START, s_cap_turn, 0);
        telemetry_log(TEL_SPEECH_DETECTED, s_cap_turn, (int32_t)(now_ms() - s_cap_start_ms), 0, NULL);
    }
    dev_settings_t st;
    settings_get(&st);
    if (s_vad.speech_detected && !s_endpoint_sent && s_vad.silence_run_ms >= st.silence_endpoint_ms) {
        s_endpoint_sent = true;
        ctrl_post_event(SM_EV_SILENCE_ENDPOINT, s_cap_turn, 0);
    }
    // Early data-path check: a full second of exact zeros means no microphone data.
    if (!s_early_fail_sent && s_vad.frames >= 50 && s_vad.zero_frames == s_vad.frames) {
        s_early_fail_sent = true;
        ESP_LOGE(TAG, "microphone delivers only zeros");
        ctrl_post_event(SM_EV_CAPTURE_FAILED, s_cap_turn, SM_ERR_CAPTURE);
    }
}

// Writes the next 20 ms of the cue program; returns false when finished.
static bool cue_step(void)
{
    if (s_prog_i >= s_prog_n) return false;
    int16_t frame[AUDIO_FRAME_SAMPLES];
    size_t filled = 0;
    while (filled < AUDIO_FRAME_SAMPLES && s_prog_i < s_prog_n) {
        segment_t *g = &s_prog[s_prog_i];
        size_t take = g->samples - s_prog_pos;
        if (take > AUDIO_FRAME_SAMPLES - filled) take = AUDIO_FRAME_SAMPLES - filled;
        if (g->pcm) memcpy(frame + filled, g->pcm + s_prog_pos, take * sizeof(int16_t));
        else memset(frame + filled, 0, take * sizeof(int16_t));
        filled += take;
        s_prog_pos += take;
        if (s_prog_pos >= g->samples) {
            s_prog_i++;
            s_prog_pos = 0;
        }
    }
    if (filled < AUDIO_FRAME_SAMPLES) memset(frame + filled, 0, (AUDIO_FRAME_SAMPLES - filled) * sizeof(int16_t));
    write_mono(frame, AUDIO_FRAME_SAMPLES);
    return true;
}

// ------------------------------------------------------------ playback -----
static uint32_t s_stream_turn;
static bool s_stream_started;
static uint32_t s_starve_since;
static int16_t s_last_sample;

static void inc_underrun(audio_stats_t *s, void *a) { (void)a; s->underruns++; }
static void add_bytes(audio_stats_t *s, void *a) { s->playback_bytes += *(uint32_t *)a; }

// Returns false when the stream has ended.
static bool stream_step(void)
{
    int16_t frame[AUDIO_FRAME_SAMPLES];
    size_t got = 0;
    bool eof, failed, mine;
    xSemaphoreTake(s_ring_mtx, portMAX_DELAY);
    mine = s_play_turn == s_stream_turn;
    size_t avail = ring_used(&s_ring);
    eof = s_play_eof;
    failed = s_play_failed;
    bool can_start = s_stream_started || avail >= AUDIO_PREFILL_BYTES || (eof && avail > 0);
    if (mine && can_start) got = ring_read(&s_ring, (uint8_t *)frame, sizeof(frame)) / sizeof(int16_t);
    xSemaphoreGive(s_ring_mtx);

    if (!mine) return false;   // superseded/stopped
    uint32_t now = now_ms();
    if (got > 0) {
        if (!s_stream_started) {
            s_stream_started = true;
            telemetry_log(TEL_PLAYBACK_STARTED, s_stream_turn, 0, 0, NULL);   // first reply audio
        }
        s_starve_since = 0;
        if (got < AUDIO_FRAME_SAMPLES) memset(frame + got, 0, (AUDIO_FRAME_SAMPLES - got) * sizeof(int16_t));
        s_last_sample = frame[got - 1];
        write_mono(frame, AUDIO_FRAME_SAMPLES);
        uint32_t b = (uint32_t)(got * sizeof(int16_t));
        stats_update(add_bytes, &b);
        return true;
    }
    if (eof) {
        bool bad = failed || !s_stream_started;
        telemetry_log(TEL_PLAYBACK_COMPLETED, s_stream_turn, 0, bad ? SM_ERR_PLAYBACK : 0, bad ? "failed" : "ok");
        ctrl_post_event(SM_EV_PLAYBACK_DONE, s_stream_turn, bad ? SM_ERR_PLAYBACK : 0);
        return false;
    }
    // Underrun / waiting for data: output silence and track starvation.
    if (s_stream_started) stats_update(inc_underrun, NULL);
    if (s_starve_since == 0) s_starve_since = now;
    if (now - s_starve_since > AUDIO_UNDERRUN_FAIL_MS) {
        telemetry_log(TEL_PLAYBACK_COMPLETED, s_stream_turn, 0, SM_ERR_PLAYBACK, "starved");
        ctrl_post_event(SM_EV_PLAYBACK_DONE, s_stream_turn, SM_ERR_PLAYBACK);
        return false;
    }
    write_mono(NULL, AUDIO_FRAME_SAMPLES);
    return true;
}

static void fade_out(void)
{
    // 10 ms ramp from the last sample to zero avoids a click on interruption.
    int16_t frame[AUDIO_FRAME_SAMPLES] = {0};
    size_t n = AUDIO_SAMPLE_RATE / 100;
    for (size_t i = 0; i < n; i++) frame[i] = (int16_t)(s_last_sample * (float)(n - i) / n);
    write_mono(frame, AUDIO_FRAME_SAMPLES);
    s_last_sample = 0;
}

// --------------------------------------------------------------- task -------
static void audio_task(void *arg)
{
    audio_mode_t mode = MODE_IDLE;
    uint32_t applied_volume_version = UINT32_MAX;
    for (;;) {
        dev_settings_t st;
        settings_get(&st);
        if (st.version != applied_volume_version && s_speaker_ok) {
            esp_codec_dev_set_out_vol(board_speaker(), st.volume);
            applied_volume_version = st.version;
        }

        audio_cmd_t c;
        TickType_t wait = (mode == MODE_IDLE) ? pdMS_TO_TICKS(50) : 0;
        while (xQueueReceive(s_cmd_q, &c, wait) == pdTRUE) {
            wait = 0;
            switch (c.type) {
            case CMD_CAPTURE_START:
                if (mode == MODE_STREAM) fade_out();
                capture_begin(c.turn);
                mode = MODE_CAPTURE;
                break;
            case CMD_CAPTURE_DISCARD:
                if (mode == MODE_CAPTURE) {
                    capture_finish(s_cap_turn, false);
                    s_cap_len = 0;
                    mode = MODE_IDLE;
                }
                break;
            case CMD_CAPTURE_SUBMIT:
                if (mode == MODE_CAPTURE) {
                    capture_finish(c.turn, true);
                    mode = MODE_IDLE;
                }
                break;
            case CMD_CUE:
                if (mode == MODE_CAPTURE) break;     // never talk over the person
                if (mode == MODE_STREAM) fade_out();
                s_prog_n = 0;
                if (c.arg == CUE_CANCEL) s_prog[s_prog_n++] = (segment_t){s_cue_cancel, s_cue_cancel_n};
                else if (c.arg == CUE_OFFLINE) s_prog[s_prog_n++] = clip(clip_offline_start, clip_offline_end);
                else s_prog[s_prog_n++] = (segment_t){s_cue_listen, s_cue_listen_n};
                program_start(false);
                mode = MODE_CUE;
                break;
            case CMD_ERROR:
                if (mode == MODE_CAPTURE) {
                    capture_stop_mic();
                    s_cap_len = 0;
                }
                if (mode == MODE_STREAM) fade_out();
                build_error_program((sm_error_t)c.arg);
                mode = MODE_CUE;
                break;
            case CMD_STREAM:
                s_stream_turn = c.turn;
                s_stream_started = false;
                s_starve_since = 0;
                mode = MODE_STREAM;
                break;
            case CMD_STOP:
                if (mode == MODE_STREAM) {
                    fade_out();
                    telemetry_log(TEL_PLAYBACK_INTERRUPTED, s_stream_turn, 0, 0, NULL);
                }
                if (mode == MODE_STREAM || mode == MODE_CUE) mode = MODE_IDLE;
                break;
            }
        }

        switch (mode) {
        case MODE_CAPTURE:
            if (s_prog_i < s_prog_n) cue_step();   // listen cue overlapping capture start
            capture_step();
            break;
        case MODE_CUE:
            if (!cue_step()) {
                if (s_prog_is_error) ctrl_post_event(SM_EV_ERROR_CUE_DONE, 0, 0);
                mode = MODE_IDLE;
            }
            break;
        case MODE_STREAM:
            if (!stream_step()) mode = MODE_IDLE;
            break;
        case MODE_IDLE:
        default:
            break;
        }
    }
}

void audio_init(bool speaker_ok, bool mic_ok)
{
    s_speaker_ok = speaker_ok;
    s_mic_ok = mic_ok;
    s_stats.speaker_ok = speaker_ok;
    s_stats.mic_ok = mic_ok;
    s_cmd_q = xQueueCreate(16, sizeof(audio_cmd_t));
    s_ring_mtx = xSemaphoreCreateMutex();
    uint8_t *ring_mem = heap_caps_malloc(AUDIO_PLAYBACK_RING, MALLOC_CAP_SPIRAM | MALLOC_CAP_8BIT);
    s_cap_buf = heap_caps_malloc(CAP_MAX * sizeof(int16_t), MALLOC_CAP_SPIRAM | MALLOC_CAP_8BIT);
    if (!ring_mem || !s_cap_buf) {
        ESP_LOGE(TAG, "PSRAM allocation failed (ring=%p capture=%p)", ring_mem, s_cap_buf);
        abort();
    }
    ring_init(&s_ring, ring_mem, AUDIO_PLAYBACK_RING);
    make_earcons();
}

void audio_mic_selftest(void)
{
    if (!s_mic_ok) return;
    esp_codec_dev_set_in_mute(board_mic(), false);
    int16_t frame[AUDIO_FRAME_SAMPLES];
    double el = 0, er = 0;
    int frames = 0, zero = 0;
    for (int i = 0; i < 25; i++) {   // 500 ms; first 100 ms discarded
        float l, r;
        if (!read_mono(frame, AUDIO_FRAME_SAMPLES, &l, &r)) break;
        if (i < 5) continue;
        frames++;
        el += l;
        er += r;
        bool all_zero = true;
        for (int k = 0; k < AUDIO_FRAME_SAMPLES * 2; k++) {
            if (s_stereo[k]) {
                all_zero = false;
                break;
            }
        }
        zero += all_zero;
    }
    esp_codec_dev_set_in_mute(board_mic(), true);
    double n = (double)frames * AUDIO_FRAME_SAMPLES;
    float dl = n > 0 && el > 0 ? (float)(20.0 * log10(sqrt(el / n) / 32768.0)) : -120.f;
    float dr = n > 0 && er > 0 ? (float)(20.0 * log10(sqrt(er / n) / 32768.0)) : -120.f;
    taskENTER_CRITICAL(&s_stats_lock);
    s_stats.selftest_rms_left = dl;
    s_stats.selftest_rms_right = dr;
    s_stats.selftest_frames = frames;
    s_stats.selftest_zero_frames = zero;
    taskEXIT_CRITICAL(&s_stats_lock);
    ESP_LOGI(TAG, "mic self-test: L %.1f dBFS, R %.1f dBFS, %d/%d all-zero frames -> %s", dl, dr, zero, frames,
             (frames > 0 && zero < frames) ? "SIGNAL PRESENT" : "NO SIGNAL");
    telemetry_log(TEL_MIC_SELFTEST, 0, (int32_t)(dl * 10), (frames > 0 && zero < frames) ? 0 : 1,
                  (frames > 0 && zero < frames) ? "signal" : "no_signal");
}

void audio_start(void)
{
    xTaskCreatePinnedToCore(audio_task, "audio", 8192, NULL, 7, NULL, 1);
}
